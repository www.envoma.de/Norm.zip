# Autodesk Inventor part: Norm (DIN)
## iProperties
Part Number: Norm (DIN)
Document SubType Name: Modeling
Density: 1 g/cm^3
Catalog Web Link: www.mittelmeyer.de
